# Keil uVision project dt_sdk.uvprojx, settings and files
target dat (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: dt
  AfterMake: fromelf --bin --output=.\bin\APP.bin  .\Objects\dat\dt.axf
  AfterMake: fromelf --text -c -o "$L@L.asm" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BR1601A02,USB_STDPERIPH_DRIVER,CFG_DT_SDK,CFG_ADV_LED,CFG_CONN_LED,CFG_DISC_IO,CFG_WKUP_MCU,CFG_SLEEP_IO,CFG_BLE_FC,CFG_KEYSCAN,xCFG_STACKTRACE,xCFG_OTA,i2616e
  c include: ..\ble\inc;..\common\inc;..\cm_backtrace\inc;..\hal\inc;..\user\inc;..\include;..\..\..\..\bsp\common\inc;..\..\..\..\bsp\core\inc;..\..\..\..\bsp\driver\inc;..\..\..\..\cs\inc
  memory RVCT4: ROM 0x1004000 size 0x3c000
  memory RVCT9: RAM 0x20004010 size 0x7ff0
  scatter file: .\dat.sct
  link misc: ..\..\..\..\cs\src\symdefs.obj
  group core
    ../../../../bsp/core/src/: system_br1601x.c
    ../core/src/: startup_br1601x.s
  group cs
    ../../../../cs/src/: cs.lib
    ./: sdk_lib.lib
  group driver
    ../../../../bsp/driver/src/: adc.c crc.c dma.c exti.c gpio.c i2c.c iwdg.c keyscan.c lpuart.c misc.c pwr.c qflash.c rcc.c rtc.c spi.c tim.c usart.c wwdg.c
  group hal
    ../hal/src/: hal_flash.c hal_gpio.c hal_uart.c
  group common
    ../../../../bsp/common/src/: co_printf.c
    ../common/src/: log.c
  group ble
    ../ble/src/: ble_adv.c ble_gap.c ble_scan.c ble_sec.c
  group ble_prf
    ../ble/src/: prf_dtss.c prf_image.c prf_gap.c prf_gatt.c prf_bas.c prf_dfu.c prf_dis.c prf_dtsc.c prf_hid.c prf_search.c prf_cmd.c
  group user
    ../user/src/: app_gpio.c app_keyscan.c app_power.c app_task.c app_whitelist.c atprocess.c cfg.c flash_manage.c it.c main.c rbuf_data.c app_ble.c app_image_protocol.c app_image_service.c app_image_at.c app_cache_owner.c app_image_staging.c app_label_adv.c app_label_adv_runtime.c app_label_info.c dfu_execute.c app_adc.c
    ../user/inc/: app_ble_cfg.h
target dat_ota (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: dt
  AfterMake: fromelf --bin --output=.\bin\APP.bin  .\Objects\dat_ota\dt.axf
  AfterMake: after_bulid.bat
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BR1601A02,USB_STDPERIPH_DRIVER,CFG_DT_SDK,CFG_ADV_LED,CFG_CONN_LED,CFG_DISC_IO,CFG_WKUP_MCU,CFG_SLEEP_IO,CFG_BLE_FC,CFG_KEYSCAN,xCFG_STACKTRACE,CFG_OTA,i2616e
  c include: ..\ble\inc;..\common\inc;..\cm_backtrace\inc;..\hal\inc;..\user\inc;..\include;..\..\..\..\tools\dfu\Image\ProgrammingDemo\Image;..\..\..\..\bsp\common\inc;..\..\..\..\bsp\core\inc;..\..\..\..\bsp\driver\inc;..\..\..\..\cs\inc
  memory RVCT4: ROM 0x1004000 size 0x3c000
  memory RVCT9: RAM 0x20004010 size 0x7ff0
  scatter file: .\dat_ota.sct
  link misc: ..\..\..\..\cs\src\symdefs.obj
