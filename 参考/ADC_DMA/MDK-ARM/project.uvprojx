# Keil uVision project project.uvprojx, settings and files
target BR1601 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: demo
  AfterMake: fromelf --bin --output=.\bin\demo.bin .\Objects\demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BR1601, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\bsp\common\inc;..\..\..\..\..\bsp\core\inc;..\..\..\..\..\bsp\driver\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ../../../../../bsp/core/src/: system_br1601x.c startup_br1601x.s
  group common
    ../../../../../bsp/common/src/: co_printf.c
  group lib
    ../../../../../cs/src/: cs.lib
  group driver
    ../../../../../bsp/driver/src/: misc.c adc.c dma.c gpio.c rcc.c usart.c lpuart.c crc.c exti.c i2c.c iwdg.c keyscan.c pwr.c qflash.c rtc.c spi.c tim.c wwdg.c
  group user
    ../src/: main.c br1601axx_it.c
  group doc
    ../: readme.txt
