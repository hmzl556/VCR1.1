# Keil uVision project ble_dtss.uvprojx, settings and files
target ble (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble +hex
  AfterMake: fromelf --bin -o "..\..\ble.bin" "#L"
  AfterMake: fromelf --text -c -o "$L@L.asm" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BR1601A01,USB_STDPERIPH_DRIVER
  c misc: --diag_suppress=188 --diag_suppress=177
  c include: ..\..\bsp\common\inc;..\..\bsp\core\inc;..\..\bsp\driver\inc;..\..\audio\audio_encode;..\..\audio\audio_code_sbc;..\..\cs\inc;..\inc;..\src;..\prj;..\..\audio\audio_code_adpcm;..\freertos\include;..\freertos;..\freertos\portable\RVDS\ARM_CM0;..\cat1;..\cat1;..\cat1\tiny-aes;..\pmu\inc;..\cat1\OTA;..\cat1\cat1;..\cat1\cat1\OTA;..\cat1\cat1\tiny-aes;..\IR
  library: MicroLIB
  memory RVCT4: ROM 0x1004000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\ble_dtss.sct
  link misc: ..\..\cs\src\symdefs.obj
  group core
    ./: system_br1601x.c startup_br1601x.s
  group freertos
    ../freertos/: tasks.c queue.c list.c app_port.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM0/: port.c
  group common
    ../../bsp/common/src/: co_printf.c
  group cs
    ../../cs/src/: cs.lib
  group user
    ../src/: app_keyscan.c task_keyscan.c task_voice.c task_ble.c app_rtos.c app_voice_ctrl.c app_encoder_sbc.c app_audio_pcm.c main.c userhard.c gmem.c blecomm.c ble_adv.c ble_gap.c ble_hid_kbd.c ble_diss.c ble_bas.c bat_adc.c combo_key.c
    ../../cs/src/: ble_dtss.c
  group cat1
    ../cat1/cat1/: aes_transport.c ble_rc_svc.c cat1_skt_udp.c cat1_time_sync.c heartbeat.c cat1_usart1.c rc_cat1_bridge.c rc_key_input.c rc_trans_assembly.c remote_reports.c cat1_udp_config.h rc_protocol.h
    ../cat1/cat1/tiny-aes/: aes.c
  group sbc_encoder
    ../src/: sbc.c sbc_primitives.c
  group driver
    ../../bsp/driver/src/: adc.c crc.c dma.c exti.c gpio.c i2c.c iwdg.c keyscan.c lpuart.c misc.c pwr.c qflash.c rcc.c rtc.c spi.c tim.c usart.c wwdg.c
  group doc
    ./: readme.txt
  group userhead
    ../inc/: userhard.h gmem.h
    ../src/: blecomm.h
  group pmu
    ../pmu/src/: pm_standby.c pm_state.c pm_sleep.c
  group OTA
    ../cat1/cat1/OTA/: ota_crc.c ota_frame.c udp_bootload.c udp_ota.c
  group IR
    ../IR/: ir_rc6.c ir_rc6_encode.c ir_raw.c ir_wave_store.c irc.c ir_learn.c ir_key_map.c
