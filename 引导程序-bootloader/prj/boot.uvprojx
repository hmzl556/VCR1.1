# Keil uVision project boot.uvprojx, settings and files
target boot (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x01000000,0x04000) IRAM(0x20004000,0x08000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BR1601A01,USB_STDPERIPH_DRIVER
  c misc: --diag_suppress=188 --diag_suppress=177
  c include: ..\..\total-随时更新\bsp\driver\inc;..\..\total-随时更新\bsp\core\inc;..\..\total-随时更新\bsp\common\inc;..\..\total-随时更新\cs\inc;..\..\total-随时更新\bleuart\cat1\OTA
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x80000
  memory RVCT9: RAM 0x20004000 size 0x8000
  scatter file: .\boot.sct
  link misc: ..\..\total-随时更新\cs\src\symdefs.obj
  group core
    ../../total-随时更新/bleuart/prj/: system_br1601x.c startup_br1601x.s
  group boot
    ../src/: boot_main.c
  group common
    ../../total-随时更新/bsp/common/src/: co_printf.c
  group OTA
    ../../total-随时更新/bleuart/cat1/OTA/: udp_bootload.c flash_layout.h
  group cs
    ../../total-随时更新/cs/src/: cs.lib
  group driver
    ../../total-随时更新/bsp/driver/src/: qflash.c misc.c gpio.c lpuart.c rcc.c
  group doc
    ./: boot.sct
